Commit message: raspbot urdf funcionando git add -A

File: raspbot_description/urdf/raspbot.urdf (robot description, URDF)
Before this commit: robot gypsy, 2 links, 2 joints
Joints:
- removed joint l_wheel_joint
